# Keil uVision project FreeRTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\freertos\Source\include;..\freertos\Source\portable\RVDS\ARM_CM7;..\User;..\freertos\Source
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c
  group FreeRTOS/Ports
    ../freertos/Source/portable/RVDS/ARM_CM7/: port.c
  group FreeRTOS/Source
    ../freertos/Source/: list.c task.c
    ../freertos/Source/include/: list.h portmacro.h FreeRTOSConfig.h FreeRTOS.h
  group doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.2.0, Device:Startup 1.1.0
